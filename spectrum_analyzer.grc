options:
  parameters:
    author: sashabusse
    copyright: '@sashabusse'
    generate_options: qt_gui
    id: spectrum_analyzer
    output_language: python
    title: spectrum analyzation and testing
  states: {}

blocks:
- name: lo_freq
  id: variable_qtgui_range
  parameters:
    label: lo frequency
    start: int(0.4e9)
    step: int(0.01e9)
    stop: int(2.1e9)
    value: int(1.990e9)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(20e6)
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: samp_rate
    bbdc: 'True'
    buffer_size: '32768'
    filter_source: '''Auto'''
    frequency: lo_freq
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
    uri: ip:192.168.3.1
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.1'
    bw: samp_rate
    fc: lo_freq
    fftsize: '16384'
    grid: 'True'
    type: complex
  states: {}

connections:
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
