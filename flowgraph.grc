options:
  parameters:
    generate_options: qt_gui
    id: flowgraph
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: carrier_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: (0, 0, 1, 1)
    label: '"carrier_freq"'
    rangeType: int
    start: int(0.6e9)
    step: int(0.001e9)
    stop: int(2.2e9)
    value: int(1.980e9)
  states: {}
- name: data_carriers_idx
  id: variable
  parameters:
    value: np.setdiff1d(np.hstack([np.arange(5, 25) , np.arange(-5, -25, -1)]), pilot_carriers_idx)
  states: {}
- name: frame_spacing
  id: variable
  parameters:
    value: '200'
  states: {}
- name: frame_sym_cnt
  id: variable
  parameters:
    value: '10'
  states: {}
- name: frame_sz
  id: variable
  parameters:
    value: ofdm_preamble.size + ofdm_sym_sz*frame_sym_cnt
  states: {}
- name: g_constellation
  id: variable
  parameters:
    value: g_qpsk_constellation
  states: {}
- name: g_qpsk_constellation
  id: variable_constellation
  parameters:
    precision: '8'
    type: qpsk
  states: {}
- name: nfft
  id: variable
  parameters:
    value: '64'
  states: {}
- name: nguard
  id: variable
  parameters:
    value: '16'
  states: {}
- name: ofdm_preamble
  id: variable
  parameters:
    value: OFDM_OOT.cox_schmerzmittel(nfft, nguard, np.hstack([np.arange(25), nfft - np.arange(1, 26)]))
  states: {}
- name: ofdm_sym
  id: variable
  parameters:
    value: OFDM_OOT.random_ofdm_sym(nfft, data_carriers_idx, pilot_carriers_idx, pilot_values)
  states: {}
- name: ofdm_sym_sz
  id: variable
  parameters:
    value: nfft+nguard
  states: {}
- name: pilot_carriers_idx
  id: variable
  parameters:
    value: np.hstack([pilot_carriers_idx_group_0 , pilot_carriers_idx_group_1])
  states: {}
- name: pilot_carriers_idx_group_0
  id: variable
  parameters:
    value: np.arange(5, 25, 4)
  states: {}
- name: pilot_carriers_idx_group_1
  id: variable
  parameters:
    value: np.arange(-5, -25, -4)
  states: {}
- name: pilot_values
  id: variable
  parameters:
    value: np.hstack([pilot_values_group_0, pilot_values_group_1])
  states: {}
- name: pilot_values_group_0
  id: variable
  parameters:
    value: 1.4 * np.exp(-2j*np.pi*np.arange(pilot_carriers_idx_group_0.size)/2)
  states: {}
- name: pilot_values_group_1
  id: variable
  parameters:
    value: 1.4 * np.exp(-2j*np.pi*np.arange(pilot_carriers_idx_group_1.size)/2)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(2e6)
  states: {}
- name: sync_autocorr_sz
  id: variable
  parameters:
    value: nfft//2 + nguard
  states: {}
- name: OFDM_OOT_BER_bbb_0
  id: OFDM_OOT_BER_bbb
  parameters:
    alpha: '1e-5'
    mode: exponential
    out_mode: lg10
  states: {state: disabled}
- name: OFDM_OOT_autocorr_cpp_cc_0
  id: OFDM_OOT_autocorr_cpp_cc
  parameters:
    conjugate_second_term: 'False'
    dn: nfft//2
    normalize: 'False'
    sz: sync_autocorr_sz
  states: {}
- name: OFDM_OOT_cfar_detector_cpp_0
  id: OFDM_OOT_cfar_detector_cpp
  parameters:
    n_search_forward: sync_autocorr_sz
    n_skip_after_detect: frame_sz
    p_false_alarm: '1e-10'
    train_regions: '[ -sync_autocorr_sz+1 - nfft, -(sync_autocorr_sz)+1]'
  states: {}
- name: OFDM_OOT_ofdm_corr_sync_demultiplex_cc_0
  id: OFDM_OOT_ofdm_corr_sync_demultiplex_cc
  parameters:
    nfft: '1024'
  states: {state: disabled}
- name: OFDM_OOT_ofdm_frame_builder_0
  id: OFDM_OOT_ofdm_frame_builder
  parameters:
    frame_sym_cnt: frame_sym_cnt
    nfft: nfft
    nguard: nguard
    preamble: ofdm_preamble
  states: {}
- name: OFDM_OOT_ofdm_preamble_sync_0
  id: OFDM_OOT_ofdm_preamble_sync
  parameters:
    frame_sym_cnt: frame_sym_cnt
    nfft: nfft
    nguard: nguard
    report_freq_off: 'True'
  states: {}
- name: OFDM_OOT_ofdm_precise_sync_cc_0
  id: OFDM_OOT_ofdm_precise_sync_cc
  parameters:
    nfft: '1024'
    pilot_groups_idx: '[[]]'
    pilot_groups_vals: '[[]]'
    report_freq_off: 'False'
  states: {state: disabled}
- name: OFDM_OOT_ofdm_precise_sync_cc_1
  id: OFDM_OOT_ofdm_precise_sync_cc
  parameters:
    nfft: nfft
    pilot_groups_idx: '[pilot_carriers_idx_group_0, pilot_carriers_idx_group_1]'
    pilot_groups_vals: '[pilot_values_group_0, pilot_values_group_1]'
    report_freq_off: 'True'
  states: {}
- name: OFDM_OOT_ofdm_retreive_data_sym_cc_0
  id: OFDM_OOT_ofdm_retreive_data_sym_cc
  parameters:
    data_carriers_idx: data_carriers_idx
    nfft: '1024'
  states: {state: disabled}
- name: OFDM_OOT_retrieve_vector_on_tag_cc_0
  id: OFDM_OOT_retrieve_vector_on_tag_cc
  parameters:
    tag: cfar
    vlen: frame_sz
  states: {}
- name: OFDM_OOT_vector_concat_0
  id: OFDM_OOT_vector_concat
  parameters:
    v1_sz: frame_sz
    v2_sz: frame_spacing
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1.4'
    type: float
  states: {state: disabled}
- name: ber_est_lg
  id: qtgui_number_sink
  parameters:
    avg: '1'
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: (1, 1, 1, 1)
    max: '3'
    min: '0'
    name: '"BER est lg"'
    type: float
  states: {state: disabled}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters:
    vlen: nfft
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_1
  id: blocks_complex_to_mag
  parameters:
    vlen: '1024'
  states: {state: disabled}
- name: blocks_complex_to_mag_1_0_0
  id: blocks_complex_to_mag
  parameters:
    vlen: nfft
  states: {}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: rx_tx_records/rx_data
    type: complex
    unbuffered: 'True'
    vlen: '1024'
  states: {state: disabled}
- name: blocks_keep_one_in_n_0
  id: blocks_keep_one_in_n
  parameters:
    n: frame_sym_cnt
    type: complex
    vlen: nfft
  states: {state: bypassed}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '[20]*1024'
    type: float
    vlen: '1024'
  states: {state: disabled}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '20'
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '1'
    vlen: '1024'
  states: {state: disabled}
- name: blocks_nlog10_ff_1
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {state: disabled}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: complex
  states: {state: disabled}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: int(np.ceil(np.log2(len(g_constellation.s_points()))))
    l: '8'
  states: {state: disabled}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: int(np.ceil(np.log2(len(g_constellation.s_points()))))
    l: '8'
  states: {state: disabled}
- name: blocks_rms_xx_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.00001'
    type: complex
  states: {state: disabled}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: int(1e3)
    type: byte
  states: {state: disabled}
- name: blocks_skiphead_0_0
  id: blocks_skiphead
  parameters:
    num_items: int(1e3)
    type: byte
  states: {state: disabled}
- name: blocks_skiphead_0_1
  id: blocks_skiphead
  parameters:
    num_items: int(1e3)
    type: complex
  states: {state: disabled}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_throttle_1_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: ofdm_sym
    vlen: nfft
  states: {}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: data_vec
  states: {state: disabled}
- name: blocks_vector_source_x_1
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: np.zeros(frame_spacing)
    vlen: frame_spacing
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '1024'
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: len(data_carriers_idx)
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_0_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: len(data_carriers_idx)
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: nfft
    type: complex
  states: {}
- name: blocks_vector_to_stream_1_0
  id: blocks_vector_to_stream
  parameters:
    num_items: frame_sz+200
    type: complex
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: (1/32)/4
    noise_voltage: '0.0'
    seed: '0'
    taps: '1'
  states: {state: disabled}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: g_constellation
  states: {state: disabled}
- name: digital_constellation_encoder_bc_0_0
  id: digital_constellation_encoder_bc
  parameters:
    constellation: g_constellation
  states: {state: disabled}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10'
    bandwidth: int(samp_rate)
    buffer_size: (frame_sz+frame_spacing)*100
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: carrier_freq
    samplerate: 1*samp_rate
    type: fc32
    uri: ip:192.168.2.1
  states: {}
- name: iio_pluto_source_0_0
  id: iio_pluto_source
  parameters:
    bandwidth: int(samp_rate)
    bbdc: 'True'
    buffer_size: (frame_sz+frame_spacing)*100
    filter_source: '''Auto'''
    frequency: carrier_freq
    gain1: '''manual'''
    manual_gain1: '64'
    quadrature: 'True'
    rfdc: 'True'
    samplerate: 1*samp_rate
    type: fc32
    uri: ip:192.168.3.1
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from gnuradio import digital
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: (4, 0, 1, 1)
    name: '"ofdm decoded symbols"'
    size: '1024'
    type: complex
    update_time: '0.2'
    xmax: '10'
    xmin: '-10'
    ymax: '5'
    ymin: '-5'
  states: {state: disabled}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: (4, 1, 1, 1)
    name: '"data symbols"'
    size: 4*len(data_carriers_idx)
    type: complex
    update_time: '0.2'
    xmax: '10'
    xmin: '-10'
    ymax: '5'
    ymin: '-5'
  states: {state: disabled}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    size: nfft
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: carrier_freq
    fftsize: '4096'
    grid: 'True'
    gui_hint: (2, 0, 1, 1)
    name: '"rx stream spectrum"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: (3, 0, 1, 2)
    name: '"prefix correlation"'
    size: '4096'
    srate: '1'
    tr_level: '0.7'
    tr_mode: qtgui.TRIG_MODE_AUTO
    tr_tag: '"packet_len"'
    type: float
    ymin: '0'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    name: '"prefix correlation"'
    size: frame_sz*5
    srate: '1'
    tr_level: '0.7'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"cfar"'
    type: float
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: '"tx time"'
    size: frame_sz*10
    srate: '1'
    type: complex
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    grid: 'True'
    gui_hint: (2, 1, 1, 1)
    name: '"ofdm symbol spectrum"'
    vlen: '1024'
    x_start: '0'
    x_step: '1.0'
    ymin: '-20'
  states: {state: disabled}
- name: qtgui_vector_sink_f_1
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    average: '0.2'
    label1: default
    name: '"RX OFDM SYM AMPLITUDE'
    vlen: nfft
    x_start: '0'
    x_step: '1.0'
  states: {}
- name: qtgui_vector_sink_f_2
  id: qtgui_vector_sink_f
  parameters:
    average: '0.2'
    label1: default
    name: '"RX OFDM SYM ARG"'
    vlen: nfft
    x_start: '0'
    x_step: '1.0'
    ymax: np.pi
    ymin: '-np.pi'
  states: {}
- name: snr_est
  id: qtgui_number_sink
  parameters:
    avg: '1'
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: (1, 0, 1, 1)
    max: '3'
    min: '0'
    name: '"SNR est"'
    type: float
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: tx_stream
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: rx_stream
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: precise_sync_out
  states: {}
- name: virtual_sink_2_0
  id: virtual_sink
  parameters:
    stream_id: coarse_sync_out
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: tx_stream
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: rx_stream
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: precise_sync_out
  states: {}

connections:
- [OFDM_OOT_BER_bbb_0, '0', ber_est_lg, '0']
- [OFDM_OOT_autocorr_cpp_cc_0, '0', OFDM_OOT_cfar_detector_cpp_0, '0']
- [OFDM_OOT_autocorr_cpp_cc_0, '1', OFDM_OOT_cfar_detector_cpp_0, '1']
- [OFDM_OOT_cfar_detector_cpp_0, '0', OFDM_OOT_retrieve_vector_on_tag_cc_0, '0']
- [OFDM_OOT_cfar_detector_cpp_0, '1', blocks_complex_to_mag_0_0, '0']
- [OFDM_OOT_ofdm_corr_sync_demultiplex_cc_0, '0', OFDM_OOT_ofdm_precise_sync_cc_0, '0']
- [OFDM_OOT_ofdm_corr_sync_demultiplex_cc_0, '0', blocks_file_sink_0_0, '0']
- [OFDM_OOT_ofdm_frame_builder_0, '0', OFDM_OOT_vector_concat_0, '0']
- [OFDM_OOT_ofdm_preamble_sync_0, '0', OFDM_OOT_ofdm_precise_sync_cc_1, '0']
- [OFDM_OOT_ofdm_preamble_sync_0, '0', virtual_sink_2_0, '0']
- [OFDM_OOT_ofdm_precise_sync_cc_0, '0', OFDM_OOT_ofdm_retreive_data_sym_cc_0, '0']
- [OFDM_OOT_ofdm_precise_sync_cc_0, '0', blocks_complex_to_mag_1, '0']
- [OFDM_OOT_ofdm_precise_sync_cc_0, '0', blocks_vector_to_stream_0, '0']
- [OFDM_OOT_ofdm_precise_sync_cc_1, '0', virtual_sink_2, '0']
- [OFDM_OOT_ofdm_retreive_data_sym_cc_0, '0', blocks_vector_to_stream_0_0, '0']
- [OFDM_OOT_ofdm_retreive_data_sym_cc_0, '0', blocks_vector_to_stream_0_0_0, '0']
- [OFDM_OOT_retrieve_vector_on_tag_cc_0, '0', OFDM_OOT_ofdm_preamble_sync_0, '0']
- [OFDM_OOT_retrieve_vector_on_tag_cc_0, '1', OFDM_OOT_ofdm_preamble_sync_0, '1']
- [OFDM_OOT_vector_concat_0, '0', blocks_vector_to_stream_1_0, '0']
- [analog_const_source_x_0, '0', blocks_divide_xx_0, '0']
- [blocks_complex_to_arg_0, '0', qtgui_vector_sink_f_2, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_mag_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_complex_to_mag_1, '0', blocks_nlog10_ff_0, '0']
- [blocks_complex_to_mag_1_0_0, '0', qtgui_vector_sink_f_1, '0']
- [blocks_divide_xx_0, '0', blocks_nlog10_ff_1, '0']
- [blocks_keep_one_in_n_0, '0', blocks_complex_to_arg_0, '0']
- [blocks_keep_one_in_n_0, '0', blocks_complex_to_mag_1_0_0, '0']
- [blocks_keep_one_in_n_0, '0', blocks_vector_to_stream_1, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_multiply_const_vxx_1, '0', snr_est, '0']
- [blocks_multiply_const_vxx_2, '0', virtual_sink_0, '0']
- [blocks_nlog10_ff_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_nlog10_ff_1, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [blocks_repack_bits_bb_0, '0', blocks_skiphead_0, '0']
- [blocks_repack_bits_bb_0_0, '0', blocks_skiphead_0_0, '0']
- [blocks_rms_xx_0, '0', blocks_divide_xx_0, '1']
- [blocks_skiphead_0, '0', OFDM_OOT_BER_bbb_0, '0']
- [blocks_skiphead_0_0, '0', OFDM_OOT_BER_bbb_0, '1']
- [blocks_skiphead_0_1, '0', blocks_rms_xx_0, '0']
- [blocks_sub_xx_0, '0', blocks_skiphead_0_1, '0']
- [blocks_throttle_1_0, '0', channels_channel_model_0, '0']
- [blocks_vector_source_x_0, '0', OFDM_OOT_ofdm_frame_builder_0, '0']
- [blocks_vector_source_x_0_0, '0', blocks_repack_bits_bb_0_0, '0']
- [blocks_vector_source_x_0_0, '0', digital_constellation_encoder_bc_0_0, '0']
- [blocks_vector_source_x_1, '0', OFDM_OOT_vector_concat_0, '1']
- [blocks_vector_to_stream_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_vector_to_stream_0_0, '0', qtgui_const_sink_x_0_0, '0']
- [blocks_vector_to_stream_0_0_0, '0', blocks_sub_xx_0, '0']
- [blocks_vector_to_stream_0_0_0, '0', digital_constellation_decoder_cb_0, '0']
- [blocks_vector_to_stream_1, '0', qtgui_const_sink_x_1, '0']
- [blocks_vector_to_stream_1_0, '0', blocks_multiply_const_vxx_2, '0']
- [channels_channel_model_0, '0', virtual_sink_1, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_repack_bits_bb_0, '0']
- [digital_constellation_encoder_bc_0_0, '0', blocks_sub_xx_0, '1']
- [iio_pluto_source_0_0, '0', virtual_sink_1, '0']
- [virtual_source_0, '0', blocks_throttle_1_0, '0']
- [virtual_source_0, '0', iio_pluto_sink_0, '0']
- [virtual_source_0, '0', qtgui_time_sink_x_2, '0']
- [virtual_source_1, '0', OFDM_OOT_autocorr_cpp_cc_0, '0']
- [virtual_source_1, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_2, '0', blocks_keep_one_in_n_0, '0']

metadata:
  file_format: 1
