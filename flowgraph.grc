options:
  parameters:
    generate_options: qt_gui
    id: flowgraph
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: carrier_freq
  id: variable_qtgui_range
  parameters:
    label: '"carrier_freq"'
    rangeType: int
    start: int(1.8e9)
    step: int(0.001e9)
    stop: int(2.2e9)
    value: int(1.980e9)
  states: {}
- name: g_bpsk_cd
  id: variable
  parameters:
    value: '{"map": [-1., 1.], "bw": 1}'
  states: {}
- name: g_cd
  id: variable
  parameters:
    value: g_qam16_cd
  states: {}
- name: g_qam16_cd
  id: variable
  parameters:
    value: '{"map": np.array(digital.qam_16()[0])[digital.qam_16()[1]]*4/np.linalg.norm(digital.qam_16()[0]), ''bw'': 4}'
  states: {}
- name: g_qpsk_cd
  id: variable
  parameters:
    value: '{"map": [-1-1j, -1+1j, 1-1j, 1+1j], "bw": 2}'
  states: {}
- name: lpf_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: samp_rate
    gain: '1.0'
    samp_rate: 4*samp_rate
    width: samp_rate/8
    win: window.WIN_HAMMING
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(1e6)
  states: {}
- name: OFDM_OOT_ofdm_corr_sync_cpp_cc_0
  id: OFDM_OOT_ofdm_corr_sync_cpp_cc
  parameters:
    corr_sz: '64'
    n_guard: '128'
    nfft: '1024'
  states: {}
- name: OFDM_OOT_ofdm_corr_sync_demultiplex_0
  id: OFDM_OOT_ofdm_corr_sync_demultiplex
  parameters:
    nfft: '1024'
  states: {}
- name: OFDM_OOT_ofdm_modulator_cc_0
  id: OFDM_OOT_ofdm_modulator_cc
  parameters:
    data_carriers_idx: '[i for i in range(2, 301, 2)]'
    n_guard: '128'
    nfft: '1024'
    pilot_carriers_idx: '[i for i in range(1, 302, 2)]'
    pilot_carriers_vals: '[1]*151'
  states: {}
- name: OFDM_OOT_ofdm_modulator_cpp_cc_0
  id: OFDM_OOT_ofdm_modulator_cpp_cc
  parameters:
    data_carriers_idx: '[i for i in range(2, 301, 2)]'
    n_guard: '128'
    nfft: '1024'
    pilot_carriers_idx: '[i for i in range(1, 302, 2)]'
    pilot_carriers_vals: '[1]*151'
  states: {state: disabled}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters:
    vlen: '1024'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/sashabusse/dev/SDR/OFDM/data/cat.jpg
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '10'
    type: complex
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: g_cd['bw']
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: g_cd['map']
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10'
    bandwidth: '20000000'
    buffer_size: int(0.1e6)
    cyclic: 'True'
    filter_source: '''Auto'''
    frequency: carrier_freq
    samplerate: samp_rate
    type: fc32
  states: {state: disabled}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: '20000000'
    bbdc: 'True'
    buffer_size: int(0.1e6)
    filter_source: '''Auto'''
    frequency: carrier_freq
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
  states: {state: disabled}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from gnuradio import digital
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    size: '4096'
    srate: '1'
    type: float
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    grid: 'True'
    vlen: '1024'
    x_start: '0'
    x_step: '1.0'
    ymax: '20'
    ymin: '0'
  states: {}

connections:
- [OFDM_OOT_ofdm_corr_sync_cpp_cc_0, '0', blocks_multiply_const_vxx_0, '0']
- [OFDM_OOT_ofdm_corr_sync_cpp_cc_0, '1', blocks_complex_to_mag_0, '0']
- [OFDM_OOT_ofdm_corr_sync_demultiplex_0, '0', blocks_complex_to_mag_0_0, '0']
- [OFDM_OOT_ofdm_modulator_cc_0, '0', blocks_throttle_0, '0']
- [OFDM_OOT_ofdm_modulator_cpp_cc_0, '0', blocks_throttle_0, '0']
- [OFDM_OOT_ofdm_modulator_cpp_cc_0, '0', iio_pluto_sink_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_mag_0_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_file_source_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', OFDM_OOT_ofdm_corr_sync_demultiplex_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [blocks_throttle_0, '0', OFDM_OOT_ofdm_corr_sync_cpp_cc_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', OFDM_OOT_ofdm_modulator_cc_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', OFDM_OOT_ofdm_modulator_cpp_cc_0, '0']
- [iio_pluto_source_0, '0', OFDM_OOT_ofdm_corr_sync_cpp_cc_0, '0']

metadata:
  file_format: 1
