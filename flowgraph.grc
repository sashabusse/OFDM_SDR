options:
  parameters:
    generate_options: qt_gui
    id: flowgraph
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: carrier_freq
  id: variable_qtgui_range
  parameters:
    label: '"carrier_freq"'
    rangeType: int
    start: int(1.8e9)
    step: int(0.001e9)
    stop: int(2.2e9)
    value: int(2.050e9)
  states: {}
- name: data_carriers_idx
  id: variable
  parameters:
    value: '[i for i in range(2, 3+2*127, 2)]'
  states: {}
- name: data_vec
  id: variable
  parameters:
    value: np.random.randint(0, 4, 1024)
  states: {}
- name: g_bpsk_cd
  id: variable
  parameters:
    value: '{"map": [-1., 1.], "bw": 1}'
  states: {}
- name: g_cd
  id: variable
  parameters:
    value: g_qpsk_cd
  states: {}
- name: g_qam16_cd
  id: variable
  parameters:
    value: '{"map": np.array(digital.qam_16()[0])[digital.qam_16()[1]]*4/np.linalg.norm(digital.qam_16()[0]), ''bw'': 4}'
  states: {}
- name: g_qpsk_cd
  id: variable
  parameters:
    value: '{"map": [-1-1j, -1+1j, 1-1j, 1+1j], "bw": 2}'
  states: {}
- name: lpf_taps
  id: variable_low_pass_filter_taps
  parameters:
    cutoff_freq: samp_rate
    gain: '1.0'
    samp_rate: 4*samp_rate
    width: samp_rate/8
    win: window.WIN_HAMMING
  states: {}
- name: pilot_carriers_idx
  id: variable
  parameters:
    value: '[i for i in range(1, 2+2*128, 2)]'
  states: {}
- name: pilot_carriers_vals
  id: variable
  parameters:
    value: ([2, -2]*(len(pilot_carriers_idx)//2)) + ([2]*(len(pilot_carriers_idx)%2))
  states: {}
- name: qpsk_constellation
  id: variable_constellation
  parameters:
    precision: '8'
    type: qpsk
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(1e6)
  states: {}
- name: OFDM_OOT_ofdm_corr_sync_cpp_cc_0
  id: OFDM_OOT_ofdm_corr_sync_cpp_cc
  parameters:
    corr_sz: '64'
    n_guard: '128'
    nfft: '1024'
  states: {}
- name: OFDM_OOT_ofdm_corr_sync_demultiplex_0
  id: OFDM_OOT_ofdm_corr_sync_demultiplex
  parameters:
    nfft: '1024'
  states: {}
- name: OFDM_OOT_ofdm_modulator_cpp_cc_0
  id: OFDM_OOT_ofdm_modulator_cpp_cc
  parameters:
    data_carriers_idx: data_carriers_idx
    n_guard: '128'
    nfft: '1024'
    pilot_carriers_idx: pilot_carriers_idx
    pilot_carriers_vals: pilot_carriers_vals
  states: {}
- name: OFDM_OOT_ofdm_precise_sync_cc_0
  id: OFDM_OOT_ofdm_precise_sync_cc
  parameters:
    nfft: '1024'
    pilot_carriers_idx: pilot_carriers_idx
    pilot_carriers_vals: pilot_carriers_vals
  states: {}
- name: OFDM_OOT_ofdm_retreive_data_sym_cc_0
  id: OFDM_OOT_ofdm_retreive_data_sym_cc
  parameters:
    data_carriers_idx: data_carriers_idx
    nfft: '1024'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_1
  id: blocks_complex_to_mag
  parameters:
    vlen: '1024'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/sashabusse/dev/SDR/OFDM/data/cat.jpg
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: complex
    vlen: '1024'
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: g_cd['bw']
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: data_vec
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '1024'
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: len(data_carriers_idx)
    type: complex
  states: {}
- name: digital_constellation_encoder_bc_0
  id: digital_constellation_encoder_bc
  parameters:
    constellation: qpsk_constellation
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '30'
    bandwidth: int(1e6)
    buffer_size: int(samp_rate*2)
    cyclic: 'True'
    filter_source: '''Auto'''
    frequency: carrier_freq
    samplerate: samp_rate
    type: fc32
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: int(1e6)
    bbdc: 'True'
    buffer_size: int(3e3)
    filter_source: '''Auto'''
    frequency: carrier_freq
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: samp_rate
    type: fc32
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from gnuradio import digital
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    size: '1000'
    type: complex
    update_time: '0.2'
    xmax: '30'
    xmin: '-30'
    ymax: '15'
    ymin: '-15'
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    size: '128'
    type: complex
    update_time: '0.2'
    xmax: '30'
    xmin: '-30'
    ymax: '15'
    ymin: '-15'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '4096'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    size: 4096*2
    srate: '1'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: float
    ymin: '0'
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    vlen: '1024'
    x_start: '0'
    x_step: '1.0'
    ymax: '20'
    ymin: '0'
  states: {}

connections:
- [OFDM_OOT_ofdm_corr_sync_cpp_cc_0, '0', OFDM_OOT_ofdm_corr_sync_demultiplex_0, '0']
- [OFDM_OOT_ofdm_corr_sync_cpp_cc_0, '0', blocks_null_sink_0, '0']
- [OFDM_OOT_ofdm_corr_sync_cpp_cc_0, '1', blocks_complex_to_mag_0, '0']
- [OFDM_OOT_ofdm_corr_sync_demultiplex_0, '0', OFDM_OOT_ofdm_precise_sync_cc_0, '0']
- [OFDM_OOT_ofdm_corr_sync_demultiplex_0, '0', blocks_null_sink_0_0, '0']
- [OFDM_OOT_ofdm_modulator_cpp_cc_0, '0', blocks_throttle_0, '0']
- [OFDM_OOT_ofdm_modulator_cpp_cc_0, '0', iio_pluto_sink_0, '0']
- [OFDM_OOT_ofdm_precise_sync_cc_0, '0', OFDM_OOT_ofdm_retreive_data_sym_cc_0, '0']
- [OFDM_OOT_ofdm_precise_sync_cc_0, '0', blocks_complex_to_mag_1, '0']
- [OFDM_OOT_ofdm_precise_sync_cc_0, '0', blocks_vector_to_stream_0, '0']
- [OFDM_OOT_ofdm_retreive_data_sym_cc_0, '0', blocks_vector_to_stream_0_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_mag_1, '0', qtgui_vector_sink_f_0, '0']
- [blocks_file_source_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', digital_constellation_encoder_bc_0, '0']
- [blocks_throttle_0, '0', OFDM_OOT_ofdm_corr_sync_cpp_cc_0, '0']
- [blocks_vector_source_x_0, '0', digital_constellation_encoder_bc_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_vector_to_stream_0_0, '0', qtgui_const_sink_x_0_0, '0']
- [digital_constellation_encoder_bc_0, '0', OFDM_OOT_ofdm_modulator_cpp_cc_0, '0']
- [iio_pluto_source_0, '0', OFDM_OOT_ofdm_corr_sync_cpp_cc_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
