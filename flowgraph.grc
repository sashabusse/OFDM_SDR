options:
  parameters:
    generate_options: qt_gui
    id: flowgraph
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: carrier_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: (0, 0, 1, 1)
    label: '"carrier_freq"'
    rangeType: int
    start: int(0.6e9)
    step: int(0.001e9)
    stop: int(2.2e9)
    value: int(1.980e9)
  states: {}
- name: data_carriers_idx
  id: variable
  parameters:
    value: np.setdiff1d(np.arange(1, 1+2*128)+40, pilot_carriers_idx)
  states: {}
- name: data_vec
  id: variable
  parameters:
    value: np.random.randint(0, len(g_constellation.s_points()), len(data_carriers_idx))
  states: {}
- name: g_constellation
  id: variable
  parameters:
    value: g_qpsk_constellation
  states: {}
- name: g_qpsk_constellation
  id: variable_constellation
  parameters:
    precision: '8'
    type: qpsk
  states: {}
- name: nfft
  id: variable
  parameters:
    value: '1024'
  states: {}
- name: nguard
  id: variable
  parameters:
    value: '128'
  states: {}
- name: pilot_carriers_idx
  id: variable
  parameters:
    value: np.arange(1, 2*128, 4) + 40
  states: {}
- name: pilot_carriers_vals
  id: variable
  parameters:
    value: 1.9 * np.exp(-2j*np.pi*np.arange(pilot_carriers_idx.size)/2)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(2e6)
  states: {}
- name: OFDM_OOT_BER_bbb_0
  id: OFDM_OOT_BER_bbb
  parameters:
    alpha: '1e-5'
    mode: exponential
    out_mode: lg10
  states: {state: disabled}
- name: OFDM_OOT_autocorr_cpp_cccc_0
  id: OFDM_OOT_autocorr_cpp_cccc
  parameters:
    dn: '32'
    sz: 32+16
  states: {}
- name: OFDM_OOT_cfar_detector_cpp_ccc_0
  id: OFDM_OOT_cfar_detector_cpp_ccc
  parameters:
    n_gap: '30'
    n_search_forward: '32'
    n_skip_after_detect: (64+16)*2
    n_train: '100'
    p_false_alarm: '0.01'
  states: {}
- name: OFDM_OOT_ofdm_corr_sync_cpp_cc_0
  id: OFDM_OOT_ofdm_corr_sync_cpp_cc
  parameters:
    corr_sz: '128'
    n_guard: '128'
    nfft: '1024'
    sync_corr_lvl: '0.9'
  states: {state: disabled}
- name: OFDM_OOT_ofdm_corr_sync_demultiplex_cc_0
  id: OFDM_OOT_ofdm_corr_sync_demultiplex_cc
  parameters:
    nfft: '1024'
  states: {state: disabled}
- name: OFDM_OOT_ofdm_corr_sync_demultiplex_cc_1
  id: OFDM_OOT_ofdm_corr_sync_demultiplex_cc
  parameters:
    nfft: '1024'
  states: {state: disabled}
- name: OFDM_OOT_ofdm_modulator_cpp_cc_0
  id: OFDM_OOT_ofdm_modulator_cpp_cc
  parameters:
    data_carriers_idx: data_carriers_idx
    n_guard: '128'
    nfft: '1024'
    pilot_carriers_idx: pilot_carriers_idx
    pilot_carriers_vals: pilot_carriers_vals
  states: {state: disabled}
- name: OFDM_OOT_ofdm_precise_sync_cc_0
  id: OFDM_OOT_ofdm_precise_sync_cc
  parameters:
    nfft: '1024'
    pilot_carriers_idx: pilot_carriers_idx
    pilot_carriers_vals: pilot_carriers_vals
  states: {state: disabled}
- name: OFDM_OOT_ofdm_retreive_data_sym_cc_0
  id: OFDM_OOT_ofdm_retreive_data_sym_cc
  parameters:
    data_carriers_idx: data_carriers_idx
    nfft: '1024'
  states: {state: disabled}
- name: OFDM_OOT_ofdm_source_1
  id: OFDM_OOT_ofdm_source
  parameters: {}
  states: {}
- name: OFDM_OOT_ofdm_symbols_stitching_0
  id: OFDM_OOT_ofdm_symbols_stitching
  parameters:
    nfft: '1024'
    nguard: '128'
  states: {state: disabled}
- name: OFDM_OOT_retrieve_vector_on_tag_cc_0
  id: OFDM_OOT_retrieve_vector_on_tag_cc
  parameters:
    tag: '''cfar'''
    vlen: ((64+16)*2)
  states: {}
- name: OFDM_OOT_test_block_0
  id: OFDM_OOT_test_block
  parameters: {}
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '1.4'
    type: float
  states: {state: disabled}
- name: ber_est_lg
  id: qtgui_number_sink
  parameters:
    avg: '1'
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: (1, 1, 1, 1)
    max: '3'
    min: '0'
    name: '"BER est lg"'
    type: float
  states: {state: disabled}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters:
    vlen: '64'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_1
  id: blocks_complex_to_mag
  parameters:
    vlen: '1024'
  states: {state: disabled}
- name: blocks_complex_to_mag_1_0
  id: blocks_complex_to_mag
  parameters:
    vlen: '1024'
  states: {state: disabled}
- name: blocks_complex_to_mag_1_0_0
  id: blocks_complex_to_mag
  parameters:
    vlen: '64'
  states: {}
- name: blocks_complex_to_mag_1_0_0_0
  id: blocks_complex_to_mag
  parameters:
    vlen: '1024'
  states: {state: disabled}
- name: blocks_delay_0
  id: blocks_delay
  parameters:
    delay: '15'
    type: complex
  states: {state: disabled}
- name: blocks_divide_xx_0
  id: blocks_divide_xx
  parameters:
    type: float
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: rx_tx_records/tx_data
    type: complex
    unbuffered: 'True'
    vlen: (1024+128)
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: rx_tx_records/rx_data
    type: complex
    unbuffered: 'True'
    vlen: '1024'
  states: {state: disabled}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: data/tmp
    type: complex
    vlen: ((64+16)*2)
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/sashabusse/dev/SDR/OFDM/data/cat.jpg
    repeat: 'True'
    type: byte
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '[20]*1024'
    type: float
    vlen: '1024'
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '[20]*1024'
    type: float
    vlen: '1024'
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '[20]*1024'
    type: float
    vlen: '1024'
  states: {state: disabled}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '20'
    type: float
  states: {state: disabled}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: complex
  states: {state: disabled}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '1'
    vlen: '1024'
  states: {state: disabled}
- name: blocks_nlog10_ff_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '1'
    vlen: '1024'
  states: {state: disabled}
- name: blocks_nlog10_ff_0_0_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '1'
    vlen: '1024'
  states: {state: disabled}
- name: blocks_nlog10_ff_1
  id: blocks_nlog10_ff
  parameters:
    k: '0'
  states: {state: disabled}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    num_inputs: '2'
    type: complex
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: g_cd['bw']
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {state: disabled}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: complex
  states: {state: disabled}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: int(np.ceil(np.log2(len(g_constellation.s_points()))))
    l: '8'
  states: {state: disabled}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: int(np.ceil(np.log2(len(g_constellation.s_points()))))
    l: '8'
  states: {state: disabled}
- name: blocks_rms_xx_0
  id: blocks_rms_xx
  parameters:
    alpha: '0.00001'
    type: complex
  states: {state: disabled}
- name: blocks_skiphead_0
  id: blocks_skiphead
  parameters:
    num_items: int(1e3)
    type: byte
  states: {state: disabled}
- name: blocks_skiphead_0_0
  id: blocks_skiphead
  parameters:
    num_items: int(1e3)
    type: byte
  states: {state: disabled}
- name: blocks_skiphead_0_1
  id: blocks_skiphead
  parameters:
    num_items: int(1e3)
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: (1024+128)
    type: complex
  states: {state: disabled}
- name: blocks_sub_xx_0
  id: blocks_sub_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_throttle_1_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: data_vec
  states: {state: disabled}
- name: blocks_vector_source_x_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: data_vec
  states: {state: disabled}
- name: blocks_vector_source_x_1
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: np.hstack([np.zeros(40), np.random.choice([-1, 1], 300) + 1j*np.random.choice([-1, 1], 300), np.zeros(1024-40-300)])
    vlen: '1024'
  states: {state: disabled}
- name: blocks_vector_source_x_1_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: np.hstack([np.zeros(40), np.random.choice([-1, 1], 300) + 1j*np.random.choice([-1, 1], 300), np.zeros(1024-40-300)])
    vlen: '1024'
  states: {state: disabled}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '1024'
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: len(data_carriers_idx)
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_0_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: len(data_carriers_idx)
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: ((64+16)*2)
    type: complex
  states: {}
- name: blocks_vector_to_stream_2
  id: blocks_vector_to_stream
  parameters:
    num_items: '1024'
    type: complex
  states: {state: disabled}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: '1.0'
    freq_offset: (1/32)/4
    noise_voltage: '0.0'
    seed: '0'
    taps: '1'
  states: {state: disabled}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: g_constellation
  states: {state: disabled}
- name: digital_constellation_encoder_bc_0
  id: digital_constellation_encoder_bc
  parameters:
    constellation: g_constellation
  states: {state: disabled}
- name: digital_constellation_encoder_bc_0_0
  id: digital_constellation_encoder_bc
  parameters:
    constellation: g_constellation
  states: {state: disabled}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '1024'
    forward: 'False'
    shift: 'False'
    type: complex
    window: window.rectangular(1024)
  states: {state: disabled}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: np.ones(16)/16
    type: ccc
  states: {state: disabled}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10'
    bandwidth: int(samp_rate)
    buffer_size: ((128+32)*1 + 16*4 + 128*2+32)*100
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: carrier_freq
    samplerate: 1*samp_rate
    type: fc32
    uri: ip:192.168.2.1
  states: {}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    bandwidth: int(samp_rate)
    bbdc: 'True'
    buffer_size: ((128+32)*1 + 16*4 + 128*2+32)*100
    filter_source: '''Auto'''
    frequency: carrier_freq
    gain1: '''slow_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: 1*samp_rate
    type: fc32
    uri: ip:192.168.3.1
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from gnuradio import digital
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: (4, 0, 1, 1)
    name: '"ofdm decoded symbols"'
    size: '1024'
    type: complex
    update_time: '0.2'
    xmax: '10'
    xmin: '-10'
    ymax: '5'
    ymin: '-5'
  states: {state: disabled}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: (4, 1, 1, 1)
    name: '"data symbols"'
    size: 4*len(data_carriers_idx)
    type: complex
    update_time: '0.2'
    xmax: '10'
    xmin: '-10'
    ymax: '5'
    ymin: '-5'
  states: {state: disabled}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: '"constellation tx"'
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_2
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    size: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: carrier_freq
    fftsize: '4096'
    grid: 'True'
    gui_hint: (2, 0, 1, 1)
    name: '"pluto source"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: (3, 0, 1, 2)
    name: '"prefix correlation"'
    size: '4096'
    srate: '1'
    tr_level: '0.7'
    tr_mode: qtgui.TRIG_MODE_AUTO
    tr_tag: '"packet_len"'
    type: float
    ymin: '0'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    name: '"prefix correlation"'
    size: (64+16)*10
    srate: '1'
    tr_level: '0.7'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"cfar"'
    type: float
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    name: '"tx_out"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0
  id: qtgui_time_sink_x
  parameters:
    name: '"rx_in"'
    size: '1024'
    srate: samp_rate
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    name: '"tx time"'
    size: 1024+128+64*16
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    grid: 'True'
    gui_hint: (2, 1, 1, 1)
    name: '"ofdm symbol spectrum"'
    vlen: '1024'
    x_start: '0'
    x_step: '1.0'
    ymin: '-20'
  states: {state: disabled}
- name: qtgui_vector_sink_f_0_0
  id: qtgui_vector_sink_f
  parameters:
    grid: 'True'
    name: '"ofdm symbol spectrum"'
    nconnections: '2'
    vlen: '1024'
    x_start: '0'
    x_step: '1.0'
    ymin: '-20'
  states: {state: disabled}
- name: qtgui_vector_sink_f_1
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    name: '"RX OFDM SYM AMPLITUDE'
    vlen: '64'
    x_start: '0'
    x_step: '1.0'
  states: {}
- name: qtgui_vector_sink_f_2
  id: qtgui_vector_sink_f
  parameters:
    name: '"RX OFDM SYM ARG"'
    vlen: '64'
    x_start: '0'
    x_step: '1.0'
    ymax: np.pi
    ymin: '-np.pi'
  states: {}
- name: snr_est
  id: qtgui_number_sink
  parameters:
    avg: '1'
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: (1, 0, 1, 1)
    max: '3'
    min: '0'
    name: '"SNR est"'
    type: float
  states: {state: disabled}

connections:
- [OFDM_OOT_BER_bbb_0, '0', ber_est_lg, '0']
- [OFDM_OOT_autocorr_cpp_cccc_0, '0', OFDM_OOT_cfar_detector_cpp_ccc_0, '0']
- [OFDM_OOT_autocorr_cpp_cccc_0, '0', blocks_delay_0, '0']
- [OFDM_OOT_autocorr_cpp_cccc_0, '0', blocks_null_sink_1, '0']
- [OFDM_OOT_autocorr_cpp_cccc_0, '1', OFDM_OOT_cfar_detector_cpp_ccc_0, '1']
- [OFDM_OOT_autocorr_cpp_cccc_0, '1', blocks_null_sink_1, '1']
- [OFDM_OOT_autocorr_cpp_cccc_0, '1', fir_filter_xxx_0, '0']
- [OFDM_OOT_cfar_detector_cpp_ccc_0, '0', OFDM_OOT_retrieve_vector_on_tag_cc_0, '0']
- [OFDM_OOT_cfar_detector_cpp_ccc_0, '1', blocks_complex_to_mag_0_0, '0']
- [OFDM_OOT_ofdm_corr_sync_cpp_cc_0, '0', OFDM_OOT_ofdm_corr_sync_demultiplex_cc_0, '0']
- [OFDM_OOT_ofdm_corr_sync_cpp_cc_0, '1', blocks_complex_to_mag_0, '0']
- [OFDM_OOT_ofdm_corr_sync_demultiplex_cc_0, '0', OFDM_OOT_ofdm_precise_sync_cc_0, '0']
- [OFDM_OOT_ofdm_corr_sync_demultiplex_cc_0, '0', blocks_file_sink_0_0, '0']
- [OFDM_OOT_ofdm_corr_sync_demultiplex_cc_1, '0', blocks_complex_to_mag_1_0, '0']
- [OFDM_OOT_ofdm_modulator_cpp_cc_0, '0', blocks_multiply_const_vxx_2, '0']
- [OFDM_OOT_ofdm_modulator_cpp_cc_0, '0', blocks_probe_rate_0, '0']
- [OFDM_OOT_ofdm_modulator_cpp_cc_0, '0', blocks_stream_to_vector_0, '0']
- [OFDM_OOT_ofdm_precise_sync_cc_0, '0', OFDM_OOT_ofdm_retreive_data_sym_cc_0, '0']
- [OFDM_OOT_ofdm_precise_sync_cc_0, '0', blocks_complex_to_mag_1, '0']
- [OFDM_OOT_ofdm_precise_sync_cc_0, '0', blocks_vector_to_stream_0, '0']
- [OFDM_OOT_ofdm_retreive_data_sym_cc_0, '0', blocks_vector_to_stream_0_0, '0']
- [OFDM_OOT_ofdm_retreive_data_sym_cc_0, '0', blocks_vector_to_stream_0_0_0, '0']
- [OFDM_OOT_ofdm_source_1, '0', blocks_vector_to_stream_1, '0']
- [OFDM_OOT_ofdm_symbols_stitching_0, '0', blocks_multiply_const_vxx_2, '0']
- [OFDM_OOT_retrieve_vector_on_tag_cc_0, '0', OFDM_OOT_test_block_0, '0']
- [OFDM_OOT_retrieve_vector_on_tag_cc_0, '0', blocks_file_sink_1, '0']
- [OFDM_OOT_retrieve_vector_on_tag_cc_0, '1', OFDM_OOT_test_block_0, '1']
- [OFDM_OOT_retrieve_vector_on_tag_cc_0, '1', blocks_null_sink_0, '0']
- [OFDM_OOT_test_block_0, '0', blocks_complex_to_arg_0, '0']
- [OFDM_OOT_test_block_0, '0', blocks_complex_to_mag_1_0_0, '0']
- [OFDM_OOT_test_block_0, '0', blocks_vector_to_stream_2, '0']
- [analog_const_source_x_0, '0', blocks_divide_xx_0, '0']
- [blocks_complex_to_arg_0, '0', qtgui_vector_sink_f_2, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_complex_to_mag_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_complex_to_mag_1, '0', blocks_nlog10_ff_0, '0']
- [blocks_complex_to_mag_1_0, '0', blocks_nlog10_ff_0_0, '0']
- [blocks_complex_to_mag_1_0_0, '0', qtgui_vector_sink_f_1, '0']
- [blocks_complex_to_mag_1_0_0_0, '0', blocks_nlog10_ff_0_0_0_0, '0']
- [blocks_delay_0, '0', OFDM_OOT_cfar_detector_cpp_ccc_0, '0']
- [blocks_divide_xx_0, '0', blocks_nlog10_ff_1, '0']
- [blocks_file_source_0, '0', blocks_packed_to_unpacked_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_multiply_const_vxx_0_0, '0', qtgui_vector_sink_f_0_0, '0']
- [blocks_multiply_const_vxx_0_0_0_0, '0', qtgui_vector_sink_f_0_0, '1']
- [blocks_multiply_const_vxx_1, '0', snr_est, '0']
- [blocks_multiply_const_vxx_2, '0', qtgui_time_sink_x_1, '0']
- [blocks_nlog10_ff_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_nlog10_ff_0_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_nlog10_ff_0_0_0_0, '0', blocks_multiply_const_vxx_0_0_0_0, '0']
- [blocks_nlog10_ff_1, '0', blocks_multiply_const_vxx_1, '0']
- [blocks_packed_to_unpacked_xx_0, '0', digital_constellation_encoder_bc_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [blocks_repack_bits_bb_0, '0', blocks_skiphead_0, '0']
- [blocks_repack_bits_bb_0_0, '0', blocks_skiphead_0_0, '0']
- [blocks_rms_xx_0, '0', blocks_divide_xx_0, '1']
- [blocks_skiphead_0, '0', OFDM_OOT_BER_bbb_0, '0']
- [blocks_skiphead_0_0, '0', OFDM_OOT_BER_bbb_0, '1']
- [blocks_skiphead_0_1, '0', blocks_rms_xx_0, '0']
- [blocks_stream_to_vector_0, '0', blocks_file_sink_0, '0']
- [blocks_sub_xx_0, '0', blocks_skiphead_0_1, '0']
- [blocks_throttle_1_0, '0', channels_channel_model_0, '0']
- [blocks_vector_source_x_0, '0', digital_constellation_encoder_bc_0, '0']
- [blocks_vector_source_x_0_0, '0', blocks_repack_bits_bb_0_0, '0']
- [blocks_vector_source_x_0_0, '0', digital_constellation_encoder_bc_0_0, '0']
- [blocks_vector_source_x_1, '0', fft_vxx_0, '0']
- [blocks_vector_source_x_1_0, '0', blocks_complex_to_mag_1_0_0_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_const_sink_x_0, '0']
- [blocks_vector_to_stream_0_0, '0', qtgui_const_sink_x_0_0, '0']
- [blocks_vector_to_stream_0_0_0, '0', blocks_sub_xx_0, '0']
- [blocks_vector_to_stream_0_0_0, '0', digital_constellation_decoder_cb_0, '0']
- [blocks_vector_to_stream_1, '0', blocks_throttle_1_0, '0']
- [blocks_vector_to_stream_1, '0', iio_pluto_sink_0, '0']
- [blocks_vector_to_stream_1, '0', qtgui_time_sink_x_2, '0']
- [blocks_vector_to_stream_2, '0', qtgui_const_sink_x_2, '0']
- [channels_channel_model_0, '0', OFDM_OOT_autocorr_cpp_cccc_0, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_repack_bits_bb_0, '0']
- [digital_constellation_encoder_bc_0, '0', OFDM_OOT_ofdm_modulator_cpp_cc_0, '0']
- [digital_constellation_encoder_bc_0, '0', qtgui_const_sink_x_1, '0']
- [digital_constellation_encoder_bc_0_0, '0', blocks_sub_xx_0, '1']
- [fft_vxx_0, '0', OFDM_OOT_ofdm_symbols_stitching_0, '0']
- [fir_filter_xxx_0, '0', OFDM_OOT_cfar_detector_cpp_ccc_0, '1']
- [iio_pluto_source_0, '0', OFDM_OOT_autocorr_cpp_cccc_0, '0']
- [iio_pluto_source_0, '0', OFDM_OOT_ofdm_corr_sync_cpp_cc_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']
- [iio_pluto_source_0, '0', qtgui_time_sink_x_1_0, '0']

metadata:
  file_format: 1
