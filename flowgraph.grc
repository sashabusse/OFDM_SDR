options:
  parameters:
    generate_options: qt_gui
    id: flowgraph
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: CFO_norm
  id: variable
  parameters:
    value: 10e-6*carrier_freq/samp_rate
  states: {}
- name: CFO_norm_max_allowed
  id: variable
  parameters:
    value: 1/(2*sync_autocorr_sh)
  states: {}
- name: Nt
  id: variable
  parameters:
    value: '100'
  states: {}
- name: SFO_norm
  id: variable
  parameters:
    value: '160e-6'
  states: {}
- name: bits_per_frame
  id: variable
  parameters:
    value: bits_per_sym*frame_sym_cnt
  states: {}
- name: bits_per_iq
  id: variable
  parameters:
    value: int(np.log2(len(data_constellation.s_points())))
  states: {}
- name: bits_per_sym
  id: variable
  parameters:
    value: data_idx.size*bits_per_iq
  states: {}
- name: bytes_per_frame
  id: variable
  parameters:
    value: bits_per_frame//8
  states: {}
- name: carrier_freq
  id: variable_qtgui_range
  parameters:
    gui_hint: (0, 0, 1, 1)
    label: '"carrier_freq"'
    rangeType: int
    start: int(0.6e9)
    step: int(0.001e9)
    stop: int(2.2e9)
    value: int(2.000e9)
  states: {}
- name: cox_s_autocorr_sh
  id: variable
  parameters:
    value: nfft//2
  states: {}
- name: cox_s_autocorr_sz
  id: variable
  parameters:
    value: nfft//2 + nguard
  states: {}
- name: data_constellation
  id: variable_constellation
  parameters:
    precision: '8'
    type: qpsk
  states: {}
- name: data_idx
  id: variable
  parameters:
    value: np.setdiff1d(np.hstack([np.arange(f_norm_min*nfft, f_norm_max*nfft, dtype=int) , np.arange(-f_norm_min*nfft, -f_norm_max*nfft, -1, dtype=int)]), pilot_idx)[:-1]
  states: {}
- name: f_norm_max
  id: variable
  parameters:
    value: '0.4'
  states: {}
- name: f_norm_min
  id: variable
  parameters:
    value: '0.1'
  states: {}
- name: frame_spacing
  id: variable
  parameters:
    value: (nfft+nguard)*20
  states: {}
- name: frame_sym_cnt
  id: variable
  parameters:
    value: '16'
  states: {}
- name: frame_sz
  id: variable
  parameters:
    value: ofdm_preamble.size + ofdm_sym_sz*frame_sym_cnt
  states: {}
- name: nfft
  id: variable
  parameters:
    value: '64'
  states: {}
- name: nguard
  id: variable
  parameters:
    value: '32'
  states: {}
- name: ofdm_preamble
  id: variable
  parameters:
    value: preamble_seqN
  states: {}
- name: ofdm_preamble_cfg
  id: variable
  parameters:
    value: preamble_seqN_cfg
  states: {}
- name: ofdm_sym_sz
  id: variable
  parameters:
    value: nfft+nguard
  states: {}
- name: pilot_idx
  id: variable
  parameters:
    value: np.hstack([pilot_idx_group_0 , pilot_idx_group_1])
  states: {}
- name: pilot_idx_group_0
  id: variable
  parameters:
    value: np.arange(f_norm_min*nfft, f_norm_max*nfft, 4, dtype=int)
  states: {}
- name: pilot_idx_group_1
  id: variable
  parameters:
    value: nfft + np.arange(-f_norm_min*nfft, -f_norm_max*nfft, -4, dtype=int)
  states: {}
- name: pilot_vals
  id: variable
  parameters:
    value: np.hstack([pilot_vals_group_0, pilot_vals_group_1])
  states: {}
- name: pilot_vals_group_0
  id: variable
  parameters:
    value: pilot_vals_group_0_zc
  states: {}
- name: pilot_vals_group_0_exp
  id: variable
  parameters:
    value: np.sqrt(2)*1.4 * np.exp(-2j*np.pi*np.arange(pilot_idx_group_0.size)/2)
  states: {}
- name: pilot_vals_group_0_zc
  id: variable
  parameters:
    value: np.sqrt(2)*1.4 *OFDM_OOT.zcsequence(3, pilot_idx_group_0.size, 0)
  states: {}
- name: pilot_vals_group_1
  id: variable
  parameters:
    value: pilot_vals_group_1_zc
  states: {}
- name: pilot_vals_group_1_exp
  id: variable
  parameters:
    value: np.sqrt(2)*1.4 * np.exp(-2j*np.pi*np.arange(pilot_idx_group_1.size)/2)
  states: {}
- name: pilot_vals_group_1_zc
  id: variable
  parameters:
    value: np.sqrt(2)*1.4 *OFDM_OOT.zcsequence(3, pilot_idx_group_0.size, 0)
  states: {}
- name: preamble_cox_s
  id: variable
  parameters:
    value: OFDM_OOT.cox_schmerzmittel(nfft, nguard, np.hstack([np.arange(25), nfft - np.arange(1, 26)]))
  states: {}
- name: preamble_cox_s_cfg
  id: variable
  parameters:
    value: OFDM_OOT.cox_schmerzmittel_cfg(nfft, nguard)
  states: {}
- name: preamble_seqN
  id: variable
  parameters:
    value: OFDM_OOT.repeat_seqN(seqN_len, seqN_N, f_border=0.35)
  states: {}
- name: preamble_seqN_cfg
  id: variable
  parameters:
    value: OFDM_OOT.repeat_seqN_cfg(seqN_len, seqN_N)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: int(0.4e6)
  states: {}
- name: seqN_N
  id: variable
  parameters:
    value: '8'
  states: {}
- name: seqN_autocorr_sh
  id: variable
  parameters:
    value: seqN_len
  states: {}
- name: seqN_autocorr_sz
  id: variable
  parameters:
    value: seqN_len*(seqN_N-1)
  states: {}
- name: seqN_len
  id: variable
  parameters:
    value: '16'
  states: {}
- name: sync_autocorr_sh
  id: variable
  parameters:
    value: seqN_autocorr_sh
  states: {}
- name: sync_autocorr_sz
  id: variable
  parameters:
    value: seqN_autocorr_sz
  states: {}
- name: test_ofdm_sym
  id: variable
  parameters:
    value: OFDM_OOT.random_ofdm_sym(nfft, data_idx, pilot_idx, pilot_vals, data_modulation='qpsk')
  states: {}
- name: OFDM_OOT_autocorr_cpp_cc_0
  id: OFDM_OOT_autocorr_cpp_cc
  parameters:
    conjugate_second_term: 'False'
    dn: sync_autocorr_sh
    normalize: 'False'
    sz: sync_autocorr_sz
  states: {}
- name: OFDM_OOT_cfar_detector_cpp_0
  id: OFDM_OOT_cfar_detector_cpp
  parameters:
    n_search_forward: int(sync_autocorr_sz*1.5)
    n_skip_after_detect: frame_sz
    p_false_alarm: '1e-35'
    train_regions: '[ -sync_autocorr_sz+1 - int(0.8*frame_spacing), -(sync_autocorr_sz)+1]'
  states: {}
- name: OFDM_OOT_channel_est_0
  id: OFDM_OOT_channel_est
  parameters:
    n_pilot_carriers: pilot_idx_group_0.size
    nfft: nfft
    pilot_carriers_idx: pilot_idx_group_0
    pilot_vals: pilot_vals_group_0
  states: {}
- name: OFDM_OOT_channel_est_hr_0
  id: OFDM_OOT_channel_est_hr
  parameters:
    Nt: Nt
    n_pilot_carriers: pilot_idx_group_0.size
    nfft: nfft
    pilot_carriers_idx: pilot_idx_group_0
    pilot_vals: pilot_vals_group_0
    sc_spacing: 1e6/nfft
  states: {}
- name: OFDM_OOT_ofdm_frame_builder_0
  id: OFDM_OOT_ofdm_frame_builder
  parameters:
    frame_sym_cnt: frame_sym_cnt
    nfft: nfft
    nguard: nguard
    preamble: ofdm_preamble
  states: {}
- name: OFDM_OOT_ofdm_preamble_sync_0
  id: OFDM_OOT_ofdm_preamble_sync
  parameters:
    cfo_est_cfg: ofdm_preamble_cfg
    compensate_cfo: 'True'
    compensate_sco: 'True'
    debug_report: 'True'
    frame_sym_cnt: frame_sym_cnt
    in_sz: frame_sz
    nfft: nfft
    nguard: nguard
    pilot_idx: pilot_idx
    sco_interp_order: '5'
    use_cfo_cp_avg_est: 'False'
  states: {}
- name: OFDM_OOT_ofdm_precise_sync_cc_1
  id: OFDM_OOT_ofdm_precise_sync_cc
  parameters:
    nfft: nfft
    pilot_groups_idx: '[pilot_idx_group_0, pilot_idx_group_1]'
    pilot_groups_vals: '[pilot_vals_group_0, pilot_vals_group_1]'
    report_freq_off: 'True'
  states: {}
- name: OFDM_OOT_retrieve_vector_on_tag_cc_0
  id: OFDM_OOT_retrieve_vector_on_tag_cc
  parameters:
    extended_zeros: '0'
    tag: cfar
    vlen: frame_sz
  states: {}
- name: OFDM_OOT_vector_assign_cc_1
  id: OFDM_OOT_vector_assign_cc
  parameters:
    data: pilot_vals
    idx: pilot_idx
    vlen: nfft
  states: {}
- name: OFDM_OOT_vector_build_by_idx_cc_0
  id: OFDM_OOT_vector_build_by_idx_cc
  parameters:
    data_idx: data_idx
    vlen_in: data_idx.size
    vlen_out: nfft
  states: {state: disabled}
- name: OFDM_OOT_vector_concat_0
  id: OFDM_OOT_vector_concat
  parameters:
    v1_sz: frame_sz
    v2_sz: frame_spacing
  states: {}
- name: OFDM_OOT_vector_retrive_by_idx_cc_0
  id: OFDM_OOT_vector_retrive_by_idx_cc
  parameters:
    data_idx: data_idx
    vlen_in: nfft
    vlen_out: data_idx.size
  states: {state: disabled}
- name: blocks_complex_to_arg_0
  id: blocks_complex_to_arg
  parameters:
    vlen: nfft
  states: {state: disabled}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    vlen: Nt
  states: {}
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_1
  id: blocks_complex_to_mag
  parameters:
    vlen: pilot_idx_group_0.size
  states: {}
- name: blocks_complex_to_mag_1_0_0
  id: blocks_complex_to_mag
  parameters:
    vlen: nfft
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: rx_tx_records/frames_last_record.bin
    type: complex
    vlen: frame_sz
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: rx_tx_records/coarse_sync_last_record.bin
    type: complex
    vlen: nfft
  states: {}
- name: blocks_file_sink_0_0_0
  id: blocks_file_sink
  parameters:
    file: rx_tx_records/precise_sync_last_record.bin
    type: complex
    vlen: nfft
  states: {}
- name: blocks_file_sink_1
  id: blocks_file_sink
  parameters:
    file: rx_tx_records/channel.bin
    type: complex
    vlen: Nt
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.4'
    type: complex
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_packed_to_unpacked_xx_0
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: bits_per_iq
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {state: disabled}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: data_idx.size
    type: complex
  states: {state: disabled}
- name: blocks_stream_to_vector_1
  id: blocks_stream_to_vector
  parameters:
    num_items: bytes_per_frame
    type: byte
  states: {state: disabled}
- name: blocks_throttle_1_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {state: disabled}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: bits_per_iq
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {state: disabled}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: test_ofdm_sym
    vlen: nfft
  states: {}
- name: blocks_vector_source_x_1
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: np.zeros(frame_spacing)
    vlen: frame_spacing
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: data_idx.size
    type: complex
  states: {state: disabled}
- name: blocks_vector_to_stream_1
  id: blocks_vector_to_stream
  parameters:
    num_items: nfft
    type: complex
  states: {}
- name: blocks_vector_to_stream_1_0
  id: blocks_vector_to_stream
  parameters:
    num_items: frame_sz+frame_spacing
    type: complex
  states: {}
- name: blocks_vector_to_stream_2
  id: blocks_vector_to_stream
  parameters:
    num_items: bytes_per_frame
    type: byte
  states: {state: disabled}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: 1+0*SFO_norm
    freq_offset: 0*CFO_norm
    noise_voltage: '0.00'
    seed: '0'
    taps: '1'
  states: {state: disabled}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: data_constellation
  states: {state: disabled}
- name: digital_constellation_encoder_bc_0
  id: digital_constellation_encoder_bc
  parameters:
    constellation: data_constellation
  states: {state: disabled}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '0'
    bandwidth: int(samp_rate)
    buffer_size: (frame_sz+frame_spacing)*10
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: carrier_freq
    samplerate: 1*samp_rate
    type: fc32
    uri: ip:192.168.3.1
  states: {}
- name: iio_pluto_source_0_0
  id: iio_pluto_source
  parameters:
    bandwidth: int(samp_rate)
    bbdc: 'True'
    buffer_size: (frame_sz+frame_spacing)*40
    filter_source: '''Auto'''
    frequency: carrier_freq
    gain1: '''fast_attack'''
    quadrature: 'True'
    rfdc: 'True'
    samplerate: 1*samp_rate
    type: fc32
    uri: ip:192.168.2.1
  states: {}
- name: import_0
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_0_0
  id: import
  parameters:
    imports: from gnuradio import digital
  states: {}
- name: import_1
  id: import
  parameters:
    imports: from gnuradio import OFDM_OOT
  states: {}
- name: qtgui_const_sink_x_1
  id: qtgui_const_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    label1: sco compensated
    size: nfft*frame_sym_cnt
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    average: '0.2'
    bw: samp_rate
    fc: carrier_freq
    fftsize: '4096'
    grid: 'True'
    gui_hint: (1, 0, 1, 2)
    name: '"rx stream spectrum"'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: (2, 0, 1, 2)
    name: '"prefix correlation"'
    size: frame_sz*5
    srate: '1'
    tr_level: '0.7'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"cfar"'
    type: float
    ymin: '0'
  states: {}
- name: qtgui_time_sink_x_2
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    name: '"tx time"'
    size: frame_sz*10
    srate: '1'
    type: complex
  states: {state: disabled}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    grid: 'True'
    vlen: Nt
    x_start: '0'
    x_step: '1.0'
  states: {}
- name: qtgui_vector_sink_f_0_0
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    grid: 'True'
    vlen: pilot_idx_group_0.size
    x_start: '0'
    x_step: '1.0'
  states: {}
- name: qtgui_vector_sink_f_1
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    average: '0.2'
    label1: default
    name: '"RX OFDM SYM AMPLITUDE'
    vlen: nfft
    x_start: '0'
    x_step: '1.0'
  states: {}
- name: qtgui_vector_sink_f_2
  id: qtgui_vector_sink_f
  parameters:
    average: '0.2'
    label1: default
    name: '"RX OFDM SYM ARG"'
    vlen: nfft
    x_start: '0'
    x_step: '1.0'
    ymax: np.pi
    ymin: '-np.pi'
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: tx_stream
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: rx_stream
  states: {}
- name: virtual_sink_2
  id: virtual_sink
  parameters:
    stream_id: precise_sync_out
  states: {}
- name: virtual_sink_2_0
  id: virtual_sink
  parameters:
    stream_id: coarse_sync_out
  states: {}
- name: virtual_sink_3
  id: virtual_sink
  parameters:
    stream_id: ofdm_data_sym_tx
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: tx_stream
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: rx_stream
  states: {}
- name: virtual_source_2
  id: virtual_source
  parameters:
    stream_id: precise_sync_out
  states: {}
- name: virtual_source_2_0
  id: virtual_source
  parameters:
    stream_id: precise_sync_out
  states: {}
- name: virtual_source_3
  id: virtual_source
  parameters:
    stream_id: ofdm_data_sym_tx
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:55557
    timeout: '100'
    type: complex
    vlen: nfft
  states: {state: disabled}
- name: zeromq_pub_sink_0_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:55556
    timeout: '100'
    type: byte
    vlen: bytes_per_frame
  states: {state: disabled}
- name: zeromq_sub_source_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:55554
    timeout: '100'
    type: byte
    vlen: bytes_per_frame
  states: {state: disabled}
- name: zeromq_sub_source_0_0
  id: zeromq_sub_source
  parameters:
    address: tcp://127.0.0.1:55555
    timeout: '100'
    type: complex
    vlen: nfft
  states: {state: disabled}

connections:
- [OFDM_OOT_autocorr_cpp_cc_0, '0', OFDM_OOT_cfar_detector_cpp_0, '0']
- [OFDM_OOT_autocorr_cpp_cc_0, '1', OFDM_OOT_cfar_detector_cpp_0, '1']
- [OFDM_OOT_cfar_detector_cpp_0, '0', OFDM_OOT_retrieve_vector_on_tag_cc_0, '0']
- [OFDM_OOT_cfar_detector_cpp_0, '0', blocks_probe_rate_0, '0']
- [OFDM_OOT_cfar_detector_cpp_0, '1', blocks_complex_to_mag_0_0, '0']
- [OFDM_OOT_channel_est_0, '0', blocks_complex_to_mag_0_1, '0']
- [OFDM_OOT_channel_est_hr_0, '0', blocks_complex_to_mag_0, '0']
- [OFDM_OOT_channel_est_hr_0, '0', blocks_file_sink_1, '0']
- [OFDM_OOT_ofdm_frame_builder_0, '0', OFDM_OOT_vector_concat_0, '0']
- [OFDM_OOT_ofdm_preamble_sync_0, '0', OFDM_OOT_ofdm_precise_sync_cc_1, '0']
- [OFDM_OOT_ofdm_preamble_sync_0, '0', blocks_file_sink_0_0, '0']
- [OFDM_OOT_ofdm_preamble_sync_0, '0', virtual_sink_2_0, '0']
- [OFDM_OOT_ofdm_precise_sync_cc_1, '0', blocks_file_sink_0_0_0, '0']
- [OFDM_OOT_ofdm_precise_sync_cc_1, '0', virtual_sink_2, '0']
- [OFDM_OOT_retrieve_vector_on_tag_cc_0, '0', OFDM_OOT_ofdm_preamble_sync_0, '0']
- [OFDM_OOT_retrieve_vector_on_tag_cc_0, '0', blocks_file_sink_0, '0']
- [OFDM_OOT_retrieve_vector_on_tag_cc_0, '1', blocks_null_sink_0, '0']
- [OFDM_OOT_vector_assign_cc_1, '0', OFDM_OOT_ofdm_frame_builder_0, '0']
- [OFDM_OOT_vector_build_by_idx_cc_0, '0', virtual_sink_3, '0']
- [OFDM_OOT_vector_concat_0, '0', blocks_vector_to_stream_1_0, '0']
- [OFDM_OOT_vector_retrive_by_idx_cc_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_complex_to_arg_0, '0', qtgui_vector_sink_f_2, '0']
- [blocks_complex_to_mag_0, '0', qtgui_vector_sink_f_0, '0']
- [blocks_complex_to_mag_0_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_complex_to_mag_0_1, '0', qtgui_vector_sink_f_0_0, '0']
- [blocks_complex_to_mag_1_0_0, '0', qtgui_vector_sink_f_1, '0']
- [blocks_multiply_const_vxx_2, '0', virtual_sink_0, '0']
- [blocks_packed_to_unpacked_xx_0, '0', digital_constellation_encoder_bc_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [blocks_stream_to_vector_0, '0', OFDM_OOT_vector_build_by_idx_cc_0, '0']
- [blocks_stream_to_vector_1, '0', zeromq_pub_sink_0_0, '0']
- [blocks_throttle_1_0, '0', channels_channel_model_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', blocks_stream_to_vector_1, '0']
- [blocks_vector_source_x_0, '0', virtual_sink_3, '0']
- [blocks_vector_source_x_1, '0', OFDM_OOT_vector_concat_0, '1']
- [blocks_vector_to_stream_0, '0', digital_constellation_decoder_cb_0, '0']
- [blocks_vector_to_stream_1, '0', qtgui_const_sink_x_1, '0']
- [blocks_vector_to_stream_1_0, '0', blocks_multiply_const_vxx_2, '0']
- [blocks_vector_to_stream_2, '0', blocks_packed_to_unpacked_xx_0, '0']
- [channels_channel_model_0, '0', virtual_sink_1, '0']
- [digital_constellation_decoder_cb_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [digital_constellation_encoder_bc_0, '0', blocks_stream_to_vector_0, '0']
- [iio_pluto_source_0_0, '0', virtual_sink_1, '0']
- [virtual_source_0, '0', blocks_throttle_1_0, '0']
- [virtual_source_0, '0', iio_pluto_sink_0, '0']
- [virtual_source_0, '0', qtgui_time_sink_x_2, '0']
- [virtual_source_1, '0', OFDM_OOT_autocorr_cpp_cc_0, '0']
- [virtual_source_1, '0', qtgui_freq_sink_x_0, '0']
- [virtual_source_2, '0', blocks_complex_to_arg_0, '0']
- [virtual_source_2, '0', blocks_complex_to_mag_1_0_0, '0']
- [virtual_source_2, '0', blocks_vector_to_stream_1, '0']
- [virtual_source_2_0, '0', OFDM_OOT_channel_est_0, '0']
- [virtual_source_2_0, '0', OFDM_OOT_channel_est_hr_0, '0']
- [virtual_source_2_0, '0', OFDM_OOT_vector_retrive_by_idx_cc_0, '0']
- [virtual_source_2_0, '0', zeromq_pub_sink_0, '0']
- [virtual_source_3, '0', OFDM_OOT_vector_assign_cc_1, '0']
- [zeromq_sub_source_0, '0', blocks_vector_to_stream_2, '0']
- [zeromq_sub_source_0_0, '0', virtual_sink_3, '0']

metadata:
  file_format: 1
